# Keil uVision project DigitalTube_Dynamic.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DigitalTube_Dynamic +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: digital_tube_dynamic.c
